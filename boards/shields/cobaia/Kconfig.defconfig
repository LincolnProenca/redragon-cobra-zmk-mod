## boards/shields/cobaia/Kconfig.defconfig
```kconfig
if SHIELD_COBAIA

config ZMK_KEYBOARD_NAME
    default "Lincoln's Mouse"

config BT_DEVICE_APPEARANCE
    default 962

endif
```
